# Keil uVision project VGA.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MKL05Z32xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.0
  cpu: IRAM(0x1FFFFC00,0x00001000) IROM(0x00000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: VGA
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x1ffffc00 size 0x1000
  group src
    ./: main.c tim.c vga.c font.c game.c tsi.c
  group inc
    ./: main.h tim.h vga.h game.h tsi.h frdm_bsp.h
software components: CMSIS Driver:SPI:Custom 1.0.0, CMSIS:CORE 5.5.0, Device:Startup 1.0.0
